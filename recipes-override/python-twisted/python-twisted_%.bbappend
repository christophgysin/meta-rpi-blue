RDEPENDS_${PN}-core += "python-numbers"
RDEPENDS_${PN}-web += "python-netserver"
